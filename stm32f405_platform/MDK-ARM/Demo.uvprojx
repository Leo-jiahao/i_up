# Keil uVision project Demo.uvprojx, settings and files
target Demo (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_HAL_DRIVER,STM32F405xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../BSP;../Middlewares/Third_Party/SEGGER_RTT/Config;../Middlewares/Third_Party/SEGGER_RTT/SEGGER;../Middlewares/Third_Party/d_flash/murmur3-master;../Middlewares/Third_Party/d_flash/src;..\Middlewares\Third_Party\i_up\BSDIFF;..\Middlewares\Third_Party\i_up\LZ77;..\Middlewares\Third_Party\r_boot\slaver;..\Middlewares\Third_Party\kp_can;..\Modules\Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  scatter file: Demo.sct
  group Application/MDK-ARM
    ./: startup_stm32f405xx.s
  group Application/User/Core
    ../Core/Src/: stm32f4xx_hal_timebase_tim.c main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Application/User/Modules
    ../Modules/Src/: usr_can.c usr_rboot.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_crc.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c
  group Drivers/BSP
    ../BSP/: stm32f405_demo1_flash.c stm32f405_demo1_can.c stm32f405_demo1_tim.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/SEGGER_RTT
    ../Middlewares/Third_Party/SEGGER_RTT/SEGGER/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group Middlewares/D_Flash
    ../Middlewares/Third_Party/d_flash/src/: d_flash.c
    ../Middlewares/Third_Party/d_flash/murmur3-master/: murmur3.c
  group Middlewares/i_up
    ../Middlewares/Third_Party/i_up/BSDIFF/: bspatch.c
    ../Middlewares/Third_Party/i_up/LZ77/: bitio.c lz77.c
  group Middlewares/r_boot/slave
    ../Middlewares/Third_Party/r_boot/slaver/: r_boot_slave.c r_boot_slave_config.h
  group Middlewares/kp_can
    ../Middlewares/Third_Party/kp_can/: can_protocol.c utilities.c
software components: CMSIS:CORE 5.6.0
